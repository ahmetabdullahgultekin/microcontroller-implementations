# Keil uVision project p4.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: p4
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: startup_stm32l476xx.s stm32l476xx.h main_basic.c system_stm32l4xx.h ssd1306_conf.h ssd1306.h ssd1306.c ssd1306_fonts.c ssd1306_fonts.h ssd1306_tests.c ssd1306_tests.h I2C.c I2C.h
software components: CMSIS:CORE 6.1.0
